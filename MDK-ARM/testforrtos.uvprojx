# Keil uVision project testforrtos.uvprojx, settings and files
target testforrtos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: testforrtos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\user\APP\LED_task;..\user\APP\detect_task;..\user\APP\remote_control;..\user\AHRS;..\user\mpu6500;..\user\DSP\Include;..\user\APP\Sensor_task;..\user\APP\usart_debug;..\user\APP\can_receive;..\user\APP\gimbal_task;..\user\APP\pid;..\user\APP\filter;..\user\APP\chassis_task;..\user\APP\auto_aim;..\user\APP\shoot_task
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c freertos.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group APP
    ../user/APP/LED_task/: LED_task.c
    ../user/APP/remote_control/: remote.c
    ../user/APP/detect_task/: detect_task.c
    ../user/APP/Sensor_task/: Sensor_task.c
    ../user/APP/usart_debug/: usart_debug.c
    ../user/APP/can_receive/: can_receive.c
    ../user/APP/chassis_task/: chassis_task.c
    ../user/APP/gimbal_task/: gimbal_task.c
    ../user/APP/pid/: pid.c
    ../user/APP/filter/: filter.c kalman_filter.c
    ../user/APP/auto_aim/: auto_aim_task.c
    ../user/APP/shoot_task/: shoot_task.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group Driver/sensor
    ../user/AHRS/: AHRS_middleware.c AHRS.lib
    ../user/mpu6500/: ist8310.c mpu6500.c
software components: CMSIS:CORE 4.3.0
